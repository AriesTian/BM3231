# Keil uVision project BK3231S_Test_Firmware.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: BK3231S_Test_Firmware +hex
  AfterMake: fromelf --bin --output .\obj\BK3231S_Test_Firmware.bin .\obj\BK3231S_Test_Firmware.axf
  AfterMake: encrypt.bat
  c flags: Optim=4 OneElfS=1
  c include: .\src\include;.\src\Driver;.\src\Core\bt\include;.\src\Core\btj_src\include;.\src\Core\hc\include;.\src\Core\hw\include;.\src\Core\lc\include;.\src\Core\lc\dl\include;.\src\Core\lc\lslc\include;.\src\Core\lc\uslc\include;.\src\Core\lmp\include;.\src\Core\sys\include;.\src\Core\transport\include;.\src\hal\hw\include;.\src\include;.\src\hal\hw\radio\bk3011\include;.\src\hal\hw\sco_codec\include;.\src\hal\prth_chimera\sys\include;.\src\Core\tc\include;.\src\App;.\src\hal\prth_chimera\hcit\include
  asm include: .\src\Core\include;.\src\BKTestApp\include;.\src\API\include
  scatter file: .\lnk\beken.txt
  group System
    ./src/hal/prth_chimera/sys/: sys_boot.s sys_fiq_irq.s
  group Hal
    ./src/hal/prth_chimera/sys/: sys_irq.c sys_mmi.c sys_hal_config.c hw_memcpy_impl.c sys_mmap.c sys_init.c sys_power.c
    ./src/hal/hw/radio/bk3011/: hw_radio.c
    ./src/hal/prth_chimera/beken/: beken_process.c
    ./src/hal/prth_chimera/hw/: hw_codec.c
  group APP
    ./src/App/: main.c config.c DeviceBtj_Handler.c DeviceBtj_Stack_Sdpdb.c
  group Driver
    ./src/Driver/: driver_flash.c driver_gpio.c driver_icu.c driver_timer.c driver_uart.c driver_WDT.c driver_xvr.c driver_adc.c Driver_spi.c
  group LIB
    ./src/lib/: BK3231S_LIB.lib
